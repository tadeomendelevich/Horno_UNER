## sdkconfig.defaults
```kconfig
CONFIG_MBEDTLS_CERTIFICATE_BUNDLE=y
CONFIG_MBEDTLS_CERTIFICATE_BUNDLE_DEFAULT_FULL=y
CONFIG_ESP_MQTT_TRANSPORT_SSL=y
CONFIG_MBEDTLS_SSL_MAX_CONTENT_LEN=16384
```
